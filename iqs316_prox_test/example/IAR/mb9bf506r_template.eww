<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mb9bf506r_template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


