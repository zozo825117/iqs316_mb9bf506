# IAR project mb9bf506r_template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\common; ..\source\app\; ..\source\app\iqs316\; ..\source\board\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf506r_template.srec
  ILINK.IlinkOutputFile: mb9bf506r_template.out
  ILINK.IlinkIcfFile: config\mb9bf506_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../Common
  ILINK.IlinkIcfFile: config\mb9bf506.icf
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: core_cm3.c system_mb9bf50x.c
  group source_files
    ../source/app/: main.c
    ./: startup_mb9bf50x.s
  group source_files/iqs316
    ../source/app/iqs316/: lower level.c upper level IQS316.c
