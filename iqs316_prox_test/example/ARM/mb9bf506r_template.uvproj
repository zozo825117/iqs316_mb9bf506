# Keil uVision project mb9bf506r_template.uvproj, settings and files
target Debug (ARM-ADS)
  device: MB9BF506R Fujitsu Microelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0007FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: mb9bf506r_template
  c flags: Optim=1
  c include: ../../Common;../source
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group common
    ../../common/: core_cm3.c system_mb9bf50x.c
  group source_files
    ../../: Readme.txt
    ./Flash/: FLASH_DEBUG_README.txt
    ../source/: adc.c main.c lcd.c key.c
    ./: startup_mb9bf50x.s
target Release (ARM-ADS)
  device: MB9BF506R Fujitsu Microelectronics
  cpu: as above
  output: mb9bf506r_template +hex
  c flags: Optim=1
  c include: ../../Common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
